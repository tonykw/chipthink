# Keil uVision project stm32_uart_spi_vk3224.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: stm_uart +hex
  c flags: Optim=1
  c define: USE_STM322xG_EVAL,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx\startup\arm;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Libraries\STM32F2xx_StdPeriph_Driver\src;..\..\user;..\..\Libraries\CMSIS\CM3;..\..\STM322xG_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.h system_stm32f2xx.c stm32f2xx.h
    ../../Libraries/CMSIS/CM3/: stm32f2xx_conf.h stm32f2xx_it.h stm32f2xx_it.c
  group driver
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_usart.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_i2c.c stm32f2xx_sdio.c stm32f2xx_syscfg.c stm32f2xx_spi.c
    ../../Libraries/STM32F2xx_StdPeriph_Driver/inc/: stm32f2xx_gpio.h stm32f2xx_rcc.h stm32f2xx_dma.h stm32f2xx_i2c.h stm32f2xx_sdio.h stm32f2xx_exti.h stm32f2xx_syscfg.h
  group user
    ../../user/: mani.c VK3224.C
  group STM322xG_EVAL
    ../../STM322xG_EVAL/: stm322xg_eval.h stm322xg_eval.c stm32_eval.h stm32_eval.c
